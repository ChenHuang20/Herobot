# Keil uVision project 405-freeRTOS.uvprojx, settings and files
target stm32f405RG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 405-freeRTOS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\bsp\Inc;..\driver\Inc;..\task\Inc;..\algorithm\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group user
    ../Src/: stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c stm32f4xx_it.c freertos.c main.c
    ../Inc/: FreeRTOSConfig.h Handle.h
  group task
    ../task/Src/: Task_SysinitConfig.c Task_ModeSwitch.c Task_PowerLimit.c Task_TakeBullet.c Task_CanSend.c Task_Monitor.c Task_Chassis.c Task_Gimbal.c Task_Debug.c Task_Shoot.c Task_DBUS.c Task_Judge.c Task_IMU.c
  group driver
    ../driver/Src/: Driver_Bell.c Driver_Stir.c Driver_CRC.c Driver_DBUS.c Driver_Vision.c Driver_Judge.c Driver_Debug.c Driver_Gimbal.c Driver_Chassis.c Driver_Friction.c Driver_Steering.c Driver_Monitor.c Driver_CanSend.c Driver_ICM20600.c Driver_PowerLimit.c Driver_SynchroBelt.c Driver_ModeSwitch.c
  group bsp
    ../bsp/Src/: BSP_SPI.c BSP_TIM.c BSP_CAN.c BSP_DMA.c BSP_NVIC.c BSP_GPIO.c BSP_UART.c
  group algorithm
    ../algorithm/Src/: Algorithm_Pid.c Algorithm_Estimator.c
  group Hallib
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c
  group startup
    ./: startup_stm32f405xx.s
    ../Src/: system_stm32f4xx.c
  group freertos
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c list.c event_groups.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.1.0
